#include <REGX51.H>

/*SBIT EN P2.7
P2.6  RS	 */
	ORG 0000H
	MOV P0,#00H
	MOV A,#01H
	ACALL COMM
	ACALL DE
	MOV A,#38H
	ACALL COMM
	ACALL DE
AG:	MOV A,#"A"
	ACALL DISP
	ACALL DE
	MOV A,#01H
	ACALL COMM
	AJMP AG


DE:	MOV R0,#0FFH
HE:		DJNZ R0,HE
		RET

DELAYL: MOV R1,#05H
HER:		DJNZ R1,HER
		RET	   

COMM: MOV P1,A
	CLR P2.6		   ;CODE DATA
	SETB P2.5		   ;R/W
	SETB P2.7		   ;ENA
	ACALL DELAYL
	CLR P2.7
	RET

 DISP: MOV P1,A
 		SETB P2.6
		SETB P2.5
		SETB P2.7
		ACALL DELAYL
		CLR P2.7
		RET


	END

 		
			