#include <REGX51.H>
	ORG 0000H
	
	DELAY: MOV R0,#4FH
A3:		MOV R1,#0FFH
A2:		MOV R2,#0FFH
A1:		DJNZ R2,A1
		DJNZ R1,A2
		DJNZ R0,A3
	

		MOV TH1,#0FDH
		MOV SCON,#50H
		MOV TMOD,#20H
		SETB TR1
		CLR A
		MOV DPTR,#0300H
		MOV R0,#09H
	AG:	MOVC A,@A+DPTR
		MOV SBUF,A
	HERE:JNB TI,HERE
		CLR TI
		CLR A
		INC DPTR
		DJNZ R0,AG


   		MOV 20H,"O"				 ;CHECK OK.
		MOV 21H,"K"
		MOV R7,#02H
		MOV R1,#20H
	CONT1:	MOV A, SBUF
	HERE1:	JNB RI,HERE1
		XRL A,@R1
	
		JZ ENDE	
		INC R1
		DJNZ R7,CONT1
		RET	
ENDE: NOP
ORG 0300H
DB "AT+CMGF=1"
	END
