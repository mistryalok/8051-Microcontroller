#include <REGX51.H>
		ORG 0000H
		MOV SCON,#50H
		MOV TMOD,#20H
		MOV TH1,#0FDH
		SETB TR1
		CLR A
	
		MOV DPTR,#0300H
		
/*		
		MOV R0,#10H
		ACALL SEND
		

		MOV R0,#03H

SEND:	MOVC A,@A+DPTR
		MOV SBUF,A
HERE:	JNB TI,HERE
		CLR TI
		CLR A	  /* CLR A TO INC COUNT. COUNT= A+DPTR*/
/*		INC DPTR
		DJNZ R0,SEND
		RET */	
		MOV R1,#20H
		MOV R0,#02H					  
		CLR RI
REC:	JNB RI,REC
		CLR RI
		MOV A,SBUF
		MOV @R1,A
		INC R6
		CLR A
		DJNZ R0,REC
		
		
			  
CHECK:	MOV A,20H
		CJNE A,#"H",EN
		MOV A,21H
		CJNE A,#"I",EN
		MOV DPTR,#0300H
		ACALL SEND
EN:	   LJMP ENDE


	SEND:	MOVC A,@A+DPTR
		MOV SBUF,A
HERE:	JNB TI,HERE
		CLR TI
		CLR A	  /* CLR A TO INC COUNT. COUNT= A+DPTR*/
	INC DPTR
		DJNZ R0,SEND
		RET 	
	
	 ORG 0300H
	 DB "OK"
ENDE:	NOP
		END