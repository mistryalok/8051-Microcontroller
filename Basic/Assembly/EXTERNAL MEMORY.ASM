#include <REGX51.H>
 ORG 0000H
 ACALL DELAY200
 MOV SCON,#50H
		MOV TMOD,#20H
		MOV TH1,#0FDH
		SETB TR1
 MOV R0,#7FH
 MOV A,#45H
 MOVX @R0,A
 CLR A
 MOV A,@R0
 ACALL SEND
 CLR C
 JNC $



SEND: CLR TI 
	MOV SBUF,A
	JNB TI,$
	CLR TI
	RET
DELAY200: MOV R2,#02H
A1:	MOV R3,#0FFH
	DJNZ R3,$
	DJNZ R2,A1
	RET
	END
