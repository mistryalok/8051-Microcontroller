		#include <REGX51.H>
		ORG 0000H
		MOV SCON,#50H
		MOV TMOD,#20H
		MOV TH1,#0FDH
		SETB TR1
		CLR A
	
		MOV DPTR,#02DDH
		
		MOV R0,#10H
		ACALL SEND
		MOV R0,#03H
		
AD:		MOV P1,#0FFH
		ACALL DELAY
		MOV A,P1
		RRC A
		JNC AD
		CLR A

	
	/*	ACALL DELAY	  */
		ACALL SEND
		LJMP ENDE
SEND:	MOVC A,@A+DPTR
		MOV SBUF,A
HERE:	JNB TI,HERE
		CLR TI
		CLR A	  /* CLR A TO INC COUNT. COUNT= A+DPTR*/
		INC DPTR
		DJNZ R0,SEND
		RET	
	
DELAY:	MOV R6,#0FFH
A3:		MOV R7,#0FFH
A2:		MOV R5,#0DFH
A1:		DJNZ R5,A1
		DJNZ R7,A2
		DJNZ R6,A3		  	 
		MOV R4,#01H
		CLR TI
		RET

DE:		MOV R6,#0FFH
		MOV R7,#0FFH
HE:		DJNZ R7,HE
		DJNZ R6,DE
		RET


ENDE:	NOP

		ORG 02DDH

	DB "ATD+918460771266ATH"	 
				END
		

		