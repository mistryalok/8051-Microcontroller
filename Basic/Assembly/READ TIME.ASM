#include <REGX51.H>
org 0000h
	ACALL DELAY200
		MOV SCON,#50H
		MOV TMOD,#20H
		MOV TH1,#0FDH
		SETB TR1

AG:	MOV R0,#00H
	MOVX A,@R0
	ACALL SEND
	ACALL DELAY
	AJMP AG


SEND:CLR TI 
	MOV SBUF,A
	JNB TI,$
	CLR TI
	RET
	
DELAY200: MOV R2,#02H
A1:	MOV R3,#0FFH
	DJNZ R3,$
	DJNZ R2,A1
	RET

DELAY: MOV R2,#45
K0:		MOV R3,#0FFH
K1:		MOV R4,#0FFH
		DJNZ R4,$
		DJNZ R3,K1
		DJNZ R2,K0
		RET
	END
		