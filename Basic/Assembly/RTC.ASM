#include <REGX51.H>
	ORG 0000H
	ACALL DELAY
	MOV R0,#0AH
	MOV A,#20H
	MOVX @R0,A

	MOV R0,#0BH
	MOV A,#83H
	MOVX @R0,A

	MOV R0,#0  ;SEC
	MOV A,#45
	MOVX @R0,A

	MOV R0,#2	  ;MIN
	MOV A,#07
	MOVX @R0,A

	MOV R0,#4	   ; HOUR
	MOV A,#19
	MOVX @R0,A

	MOV R0,#6		  ;DAY OF WEEK
	MOV A,#6
	MOVX @R0,A

	INC R0				
	MOV A,#12			;DATE
	MOVX @R0,A

	INC R0
	MOV A,#10
	MOVX @R0,A

	INC R0
	MOV A,#12
	MOVX @R0,A

	MOV R0,#11
	MOV A,#03
	MOVX @R0,A

		ACALL DELAY200
		MOV SCON,#50H
		MOV TMOD,#20H
		MOV TH1,#0FDH
		SETB TR1

AG:	MOV R0,#00H
	MOVX A,@R0
	ACALL SEND
	ACALL DELAYM
	AJMP AG


SEND:CLR TI 
	MOV SBUF,A
	JNB TI,$
	CLR TI
	RET
	
DELAY200: MOV R2,#02H
A1:	MOV R3,#0FFH
	DJNZ R3,$
	DJNZ R2,A1
	RET

DELAYM: MOV R2,#45
K0:		MOV R3,#0FFH
K1:		MOV R4,#0FFH
		DJNZ R4,$
		DJNZ R3,K1
		DJNZ R2,K0
		RET

DELAY: MOV R2,#02H
A6:	MOV R3,#0FFH
	DJNZ R3,$
	DJNZ R2,A6
	RET

END

